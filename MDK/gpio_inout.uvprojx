# Keil uVision project gpio_inout.uvprojx, settings and files
target gpio_inout_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L110C6UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GUaBaoHe_Relay101 +hex
  c flags: OneElfS=1
  c include: ..\common;..\source;..\driver\inc;..\APP;.\CMSIS 5.9.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ../common/: system_hc32l110.c startup_hc32l110.s
  group source
    ../source/: key.c led.c sys.c usart.c strs.c TG.c main.c timers.c
  group driver
    ../driver/src/: ddl.c gpio.c interrupts_hc32l110.c clk.c bt.c uart.c flash.c wdt.c
  group APP
    ../APP/: xunSub.c RelayApp.c
software components: CMSIS:CORE 5.1.2
